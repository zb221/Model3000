# Keil uVision project Model-3000.uvproj, settings and files
target 3000 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2194 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Model-3000
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group start
    ./: Startup.s
  group user
    ./: Main.c
